## config/boards/shields/testkeyboard/Kconfig.defconfig
```kconfig
if SHIELD_TESTKEYBOARD

config ZMK_KEYBOARD_NAME    
    default "testkeyboard"

endif
```
